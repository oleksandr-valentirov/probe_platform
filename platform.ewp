# IAR project platform.ewp, settings and files
configuration F4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F411xE; ENABLE_GPGGA
  ICCARM.CCIncludePath2: Projects_Library\F4\; Projects_Library\F4\CMSIS\; Projects_Library\F4\CMSIS\inc\; Projects_Library\F4\CMSIS\src\; Projects_Library\F4\STM32F4xx_StdPeriph_Driver\; Projects_Library\F4\STM32F4xx_StdPeriph_Driver\inc\; Projects_Library\F4\STM32F4xx_StdPeriph_Driver\src\; Projects_Library\F4\Drivers\ADC; Projects_Library\F4\Drivers\USART; Projects_Library\F4\Drivers\SPI; Projects_Library\F4\Drivers\SystemClock; Projects_Library\F4\Drivers\GPIO; Projects_Library\F4\Drivers\timers; Projects_Library\F4\Drivers\OneWire; Projects_Library\F4\Drivers\I2C; Projects_Library\F4\Modules\SX1268; Projects_Library\F4\Modules\SIM800; Projects_Library\F4\Modules\GPS; Projects_Library\F4\Modules\GPS\uBlox; Projects_Library\F4\Modules\TemperatureSensorsAPI
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: platform.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Projects_Library\F4\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration F3 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Projects_Library\F3\; Projects_Library\F3\CMSIS\; Projects_Library\F3\CMSIS\inc\; Projects_Library\F3\CMSIS\src\; Projects_Library\F3\StdPeriph\; Projects_Library\F3\StdPeriph\inc\; Projects_Library\F3\StdPeriph\src\; Projects_Library\F3\Drivers\SystemClock\; Projects_Library\F3\Drivers\timers\; Projects_Library\F3\Drivers\GPIO\; Projects_Library\F3\Modules\OneWire\
  ICCARM.CCOptLevel: 0
  ILINK.IlinkOutputFile: platform.out
  ILINK.IlinkIcfFile: Projects_Library\F3\stm32f10x_flash.icf
  group F3
    Projects_Library/F3/: !Project_Library.h main.c Pin_Configuration.h stm32f10x_conf.h
  group F3/CMSIS
    Projects_Library/F3/CMSIS/: startup_stm32f103xb.s
  group F3/CMSIS/inc
    Projects_Library/F3/CMSIS/inc/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h stm32f103xb.h stm32f10x.h stm32f1xx.h system_stm32f10x.h system_stm32f1xx.h
  group F3/CMSIS/src
    Projects_Library/F3/CMSIS/src/: core_cm3.c system_stm32f10x.c system_stm32f1xx.c
  group F3/Drivers/GPIO
    Projects_Library/F3/Drivers/GPIO/: gpio.c gpio.h
  group F3/Drivers/SystemClock
    Projects_Library/F3/Drivers/SystemClock/: clock.c clock.h
  group F3/Drivers/timers
    Projects_Library/F3/Drivers/timers/: timers.c timers.h
  group F3/Modules/OneWire
    Projects_Library/F3/Modules/OneWire/: onewire.c onewire.h
  group F3/StdPeriph
    Projects_Library/F3/StdPeriph/: stm32f10x_it.c stm32f10x_it.h
  group F3/StdPeriph/inc
    Projects_Library/F3/StdPeriph/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group F3/StdPeriph/src
    Projects_Library/F3/StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group F4
    Projects_Library/F4/: !Project_library.h main.c Pin_Configuration.h stm32f4xx_conf.h
  group F4/CMSIS
    Projects_Library/F4/CMSIS/: startup_stm32f411xe.s
  group F4/CMSIS/inc
    Projects_Library/F4/CMSIS/inc/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h stm32f4xx.h system_stm32f4xx.h
  group F4/CMSIS/src
    Projects_Library/F4/CMSIS/src/: system_stm32f4xx.c
  group F4/Drivers/ADC
    Projects_Library/F4/Drivers/ADC/: ADC.c ADC.h
  group F4/Drivers/GPIO
    Projects_Library/F4/Drivers/GPIO/: gpio.c gpio.h
  group F4/Drivers/I2C
    Projects_Library/F4/Drivers/I2C/: i2c.c i2c.h
  group F4/Drivers/OneWire
    Projects_Library/F4/Drivers/OneWire/: onewire.c onewire.h
  group F4/Drivers/SPI
    Projects_Library/F4/Drivers/SPI/: SPI.c SPI.h
  group F4/Drivers/SystemClock
    Projects_Library/F4/Drivers/SystemClock/: clock.c clock.h
  group F4/Drivers/timers
    Projects_Library/F4/Drivers/timers/: systick.c systick.h timers.c timers.h
  group F4/Drivers/USART
    Projects_Library/F4/Drivers/USART/: USART1.c USART1.h USART2.c USART2.h
  group F4/Modules/GPS
    Projects_Library/F4/Modules/GPS/: gps.c gps.h
  group F4/Modules/GPS/uBlox
    Projects_Library/F4/Modules/GPS/uBlox/: m8.c m8.h
  group F4/Modules/SIM800
    Projects_Library/F4/Modules/SIM800/: sim.c sim.h
  group F4/Modules/SX1268
    Projects_Library/F4/Modules/SX1268/: sx126x.c sx126x.h
  group F4/Modules/TemperatureSensorsAPI
    Projects_Library/F4/Modules/TemperatureSensorsAPI/: temp_api.c temp_api.h
  group F4/StdPeriph
    Projects_Library/F4/STM32F4xx_StdPeriph_Driver/: stm32f4xx_it.c stm32f4xx_it.h
  group F4/StdPeriph/inc
    Projects_Library/F4/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group F4/StdPeriph/src
    Projects_Library/F4/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
